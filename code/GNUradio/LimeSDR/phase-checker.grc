<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>4e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fs</value></param>
<param><key>value</key><value>16000000</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>num_items</key><value>fs*3/2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>input_file_source</value></param>
<param><key>file</key><value>/home/nsbruce/Documents/UViip/MATLAB/Phase-locking/tx_symbol</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>8000000</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value>soapy=0,driver=lime</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>fs</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>8000000</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>25</value></param>
<param><key>args</key><value>soapy=0,driver=lime</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>fs</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>output_file_sink</value></param>
<param><key>file</key><value>/home/nsbruce/Documents/UViip/MATLAB/Phase-locking/rx_data</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>output_file_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>input_file_source</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
